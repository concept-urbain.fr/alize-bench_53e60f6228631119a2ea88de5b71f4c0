Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Alize Banc.IFC
Time: 2020-06-26T13:15:47
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: EUROALIZ-MULT-003_Default (2)
In: Default Storey
Name
EUROALIZ-MULT-003_Default | PSet_Mass_Property - Mass Measure: 44589.6; Area Measure: 4689287; Volume Measure: 7411996
EUROALIZ-MULT-003_Default
